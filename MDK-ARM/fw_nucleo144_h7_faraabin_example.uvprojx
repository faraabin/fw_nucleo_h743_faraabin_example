# Keil uVision project fw_nucleo144_h7_faraabin_example.uvprojx, settings and files
target fw_nucleo144_h7_faraabin_example (5060960::V5.06 update 7 for Certification (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: fw_nucleo144_h7_faraabin_example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\src;..\src\third_party\CMSIS\Include;..\src\third_party\CMSIS\Device\ST\STM32H7xx\Include;..\src\system;..\src\hal\stm32h7xx_mhal\inc;..\src\hal\stm32h7xx_mhal\inc\Legacy;..\src\hal\stm32h7xx_phal\inc;..\src\bsp\bsp_nucleo144_h7\inc;..\src\library;..\src\library\boot_message;..\src\library\chrono;..\src\library\cpu_profiler;..\src\library\i_driver;..\src\library\modbus;..\src\library\state_machine;..\src\library\sw_faraabin\lib;..\src\library\sw_parameter_cogen\lib;..\src\library\unity;..\src\library\utility\;..\src\library\utility\io;..\src\app;..\src\app\app_integrator\conf;..\src\app\resources;..\src\library\utility\dsp;..\src\library\runtime_scaler;..\src\third_party\CMSIS\DSP\Include;..\src\library\cdrv\cdrv_wiz850io\ioLibrary_Driver-master
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group app/core
    ./: startup_stm32h743xx.s
    ../src/system/: main.c stm32h7xx_it.c system_stm32h7xx.c
  group app
    ../src/app/app_integrator/: app_integrator.c
    ../src/app/resources/: resources.c
    ../src/app/mapp_code_block/: mapp_code_block.c
    ../src/app/mapp_cpu_profiler/: mapp_cpu_profiler.c
    ../src/app/mapp_databus/: mapp_databus.c
    ../src/app/mapp_event_group/: mapp_event_group.c
    ../src/app/mapp_fsm/: mapp_fsm.c
    ../src/app/mapp_function/: mapp_function.c mapp_function_fn.c
    ../src/app/mapp_state_machine/: mapp_state_machine.c
    ../src/app/mapp_unity/: mapp_unity.c mapp_unity_fn.c mapp_unity_tests.c
    ../src/app/mapp_variable/: mapp_variable_primitive.c mapp_variable_ramp.c mapp_variable_sin.c mapp_variable_user_defined.c mapp_variable_user_defined_cg.c
    ../src/third_party/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group app/port
    ../src/app/app_integrator/port/: faraabin_port.c
  group cdrv
    ../src/library/cdrv/cdrv_wiz850io/ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
    ../src/library/cdrv/cdrv_wiz850io/ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ../src/library/cdrv/cdrv_wiz850io/ioLibrary_Driver-master/ex/: ex_tcp_udp_server.c
    ../src/library/cdrv/cdrv_wiz850io/ioLibrary_Driver-master/: cdrv_wiz850io_ofn.c cdrv_wiz850io.c
  group bsp_nucleo144
    ../src/bsp/bsp_nucleo144_h7/src/: bsp_sys.c bsp.c
  group phal
    ../src/hal/stm32h7xx_phal/src/: stm32h7xx_phal.c stm32h7xx_phal_clock.c stm32h7xx_phal_delay.c stm32h7xx_phal_gpio.c stm32h7xx_phal_spi.c stm32h7xx_phal_tick.c stm32h7xx_phal_timer.c stm32h7xx_phal_uart.c
  group mhal
    ../src/hal/stm32h7xx_mhal/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_ll_gpio.c stm32h7xx_hal_mdma.c
  group lib/faraabin/add_on
    ../src/library/sw_faraabin/lib/add_on/cpu_profiler/: faraabin_addon_cpu_profiler.c
    ../src/library/sw_faraabin/lib/add_on/state_machine/: faraabin_addon_state_machine.c
    ../src/library/sw_faraabin/lib/add_on/unity/: faraabin_addon_unity.c
  group lib/faraabin
    ../src/library/sw_faraabin/lib/: faraabin.c
  group lib/cpu_profiler
    ../src/library/cpu_profiler/: cpu_profiler.c
  group lib/chrono
    ../src/library/chrono/: chrono.c
  group lib/state_machine
    ../src/library/state_machine/: state_machine.c
  group lib/utility/memory
    ../src/library/utility/memory/data_structure/: queue.c queue_external.c queue_ofn.c
    ../src/library/utility/checksum/: checksum.c
    ../src/library/i_driver/memory_test/: memory_test.c
  group lib/utility/app_manager
    ../src/library/utility/app_manager/: app_manager.c app_manager_fn.c
  group lib/utility/observer
    ../src/library/utility/observer/: observer.c
  group lib/utility/time
    ../src/library/utility/time/: date_time.c
  group lib/utility/dsp
    ../src/library/utility/dsp/: debounce.c edge.c ramp.c
  group lib/utility/io
    ../src/library/utility/io/: contactor.c jumper.c led.c led_ofn.c led_rgb_ofn.c pb.c pb_ofn.c
  group lib/unity
    ../src/library/unity/: unity.c unity_fixture.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
